# IAR project GEC-CB-BL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_USB_OTG_FS; GEC_CB_BOOTLOADER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\App; ..\FATFS\src; ..\FATFS\exfuns; ..\SYSTEM; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\24CXX; ..\HARDWARE\IIC; ..\HARDWARE\DIGITAL_LED; ..\HARDWARE\EWDT; ..\HARDWARE\STMFLASH; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\IAP; ..\MALLOC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GEC-CB-BL.hex
  ILINK.IlinkOutputFile: GEC-CB-BL.out
  ILINK.IlinkIcfFile: stm32f10x_flash_bl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: hw_test.c update.c usb_bsp.c usbh_usr.c
  group FATFS
    ../FATFS/src/option/: ccsbcs.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLib/SRC
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAREWARE
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/DIGITAL_LED/: digital_led.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MB85RCXX/: mb85rcxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group IAP
    ../IAP/: iap.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group USB_Host/Class/MSC
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_Host/Core
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USER
    ../App/: main.c
    ./: stm32f10x_conf.h stm32f10x_it.c

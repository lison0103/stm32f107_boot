# IAR project GEC-CB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_USB_OTG_FS; GEC_CB_MAIN
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\Libraries\Third_Party\FreeRTOS\Source\include; ..\Libraries\Third_Party\FreeRTOS\source\portable\IAR\ARM_CM3; ..\Libraries\STM32F107_ETH_Driver\inc; ..\Libraries\Third_Party\lwip-1.4.1\src\include\; ..\Libraries\Third_Party\lwip-1.4.1\src\include\lwip; ..\Libraries\Third_Party\lwip-1.4.1\src\include\netif; ..\Libraries\Third_Party\lwip-1.4.1\src\include\ipv4; ..\Libraries\Third_Party\lwip-1.4.1\port\STM32F107; ..\Libraries\Third_Party\lwip-1.4.1\port\STM32F107\FreeRTOS\; ..\Libraries\Third_Party\freemodbus-v1.5.0\demo\BARE\port; ..\Libraries\Third_Party\freemodbus-v1.5.0\modbus\include; ..\Libraries\Third_Party\freemodbus-v1.5.0\modbus\tcp; ..\Libraries\Third_Party\freemodbus-v1.5.0\modbus\rtu; ..\App; ..\FATFS\src; ..\FATFS\exfuns; ..\SYSTEM; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\24CXX; ..\HARDWARE\IIC; ..\HARDWARE\DIGITAL_LED; ..\HARDWARE\EWDT; ..\HARDWARE\STMFLASH; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\IAP; ..\MALLOC; ..\ETHERNET; ..\SELFTEST\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: GEC-CB.bin
  ILINK.IlinkOutputFile: GEC-CB.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: bsp_iocfg.c freertos_lwip.c hw_test.c initial_devices.c mbserver.c modbusTask.c self_test.c update.c usb_bsp.c usbh_usr.c
  group FATFS
    ../FATFS/src/option/: ccsbcs.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
  group FreeModbus/modbus
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/: mb.c
  group FreeModbus/modbus/functions
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FreeModbus/modbus/include
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group FreeModbus/modbus/rtu
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbrtu.c
  group FreeModbus/modbus/tcp
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/tcp/: mbtcp.c mbtcp.h
  group FreeModbus/port
    ../Libraries/Third_Party/freemodbus-v1.5.0/demo/BARE/port/: port.h portevent.c portserial.c porttcp.c porttimer.c
  group FreeRTOS
    ../Libraries/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c freertos_timers.c list.c queue.c tasks.c
  group FreeRTOS/inc
    ../Libraries/Third_Party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable
    ../Libraries/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Libraries/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FWLib/CMSIS
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLib/SRC
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/STM32F107_ETH_Driver/src/: stm32f107_eth.c
    ../Libraries/STM32F107_ETH_Driver/inc/: stm32f107_eth.h
  group HAREWARE
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/DIGITAL_LED/: digital_led.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MB85RCXX/: mb85rcxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group IAP
    ../IAP/: iap.c
  group LWIP-1.4.1/API
    ../Libraries/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-1.4.1/CORE
    ../Libraries/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-1.4.1/CORE/IPV4
    ../Libraries/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-1.4.1/NETIF
    ../Libraries/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../Libraries/Third_Party/lwip-1.4.1/port/STM32F107/FreeRTOS/: ethernetif.c sys_arch.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SELFTEST
    ../SELFTEST/src/: check_instruction.c check_instruction_post.s check_instruction_post_2.s clock_test.c config_test.c cpu_reg_test.c cpu_reg_test_post.s flag_test.c flash_test.c pc_test.c ram_test.c wdt_test.c
  group SELFTEST/inc
    ../SELFTEST/inc/: check_instruction.h check_instruction_2.h clock_test.h config_test.h cpu_reg_test.h flag_test.h flash_test.h iec61508.h pc_test.h ram_test.h stack_test.h wdt_test.h
  group SYSTEM
    ../SYSTEM/: delay.c lsys.c usart.c
  group USB_Host/Class/MSC
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_Host/Core
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USER
    ./: FreeRTOSConfig.h includes.h main.c stm32f10x_conf.h stm32f10x_it.c
    ../ETHERNET/: lwipopts.h netconf.c stm32_eth_bsp.c stm32f107_eth_conf.h
